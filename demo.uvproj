# Keil uVision project demo.uvproj, settings and files
target Target_1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: demo +hex
  group Src
    ./Src/: main.c fan.c isr.c tick.c imu.c hmc5883l.c pid.c task.c
  group Inc
    ./Inc/: main.h fan.h isr.h tick.h imu.h hmc5883l.h pid.h task.h
  group startup
    ./Libraries/libraries/: board.c board.h common.c common.h STC32Gxx.h
  group seekfree_libraries
    ./Libraries/seekfree_peripheral/: headfile.h
    ./Libraries/seekfree_libraries/: zf_adc.c zf_adc.h zf_delay.c zf_delay.h zf_eeprom.c zf_eeprom.h zf_exti.c zf_exti.h zf_gpio.c zf_gpio.h zf_nvic.c zf_nvic.h zf_pwm.c zf_pwm.h zf_spi.c zf_spi.h zf_tim.c zf_tim.h zf_uart.c zf_uart.h zf_fifo.c zf_fifo.h zf_function.c zf_function.h zf_iic.c zf_iic.h
  group seekfree_peripheral
    ./Libraries/seekfree_peripheral/: headfile.h SEEKFREE_18TFT.c SEEKFREE_18TFT.h SEEKFREE_BLE6A20.c SEEKFREE_BLE6A20.h SEEKFREE_BLUETOOTH_CH9141.c SEEKFREE_BLUETOOTH_CH9141.h SEEKFREE_CONFIG.LIB SEEKFREE_CONFIG.h SEEKFREE_DL1A.c SEEKFREE_DL1A.h SEEKFREE_DL1B.c SEEKFREE_DL1B.h SEEKFREE_FONT.c SEEKFREE_FONT.h SEEKFREE_ICM20602.c SEEKFREE_ICM20602.h SEEKFREE_IMU660RA.c SEEKFREE_IMU660RA.h SEEKFREE_IMU963RA.c SEEKFREE_IMU963RA.h SEEKFREE_IPS114_SPI.c SEEKFREE_IPS114_SPI.h SEEKFREE_MPU6050.c SEEKFREE_MPU6050.h SEEKFREE_OLED.c SEEKFREE_OLED.h SEEKFREE_PRINTF.c SEEKFREE_PRINTF.h SEEKFREE_TSL1401.c SEEKFREE_TSL1401.h SEEKFREE_VIRSCO.c SEEKFREE_VIRSCO.h SEEKFREE_WIRELESS.c SEEKFREE_WIRELESS.h SEEKFREE_GPS_TAU1201.c SEEKFREE_GPS_TAU1201.h
  group seekfree_components
    ./Libraries/seekfree_components/: seekfree_assistant.c seekfree_assistant.h seekfree_assistant_inface.c
